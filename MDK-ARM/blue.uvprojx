# Keil uVision project blue.uvprojx, settings and files
target blue (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: blue +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP;../Drivers/SYSTERM/delay;../Drivers/SYSTERM/sys;../Drivers/SYSTERM/usart;../Drivers/BSP/OLED;../Drivers/BSP/DHT11;../Drivers/BSP/MQ2;../Drivers/BSP/RC522;../Drivers/BSP/StepMotor;../Drivers/BSP/Fire;../Drivers/BSP/DS1820;../Drivers/BSP/KEY
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/BSP
    ../Drivers/BSP/OLED/: oled.c
    ../Drivers/BSP/DHT11/: dht11.c
    ../Drivers/BSP/MQ2/: mq2.c
    ../Drivers/BSP/RC522/: RC522.c
    ../Drivers/BSP/StepMotor/: step_motor.c
    ../Drivers/BSP/Fire/: Fire.c
    ../Drivers/BSP/DS1820/: DS1820.c
    ../Drivers/BSP/KEY/: key.c
  group Drivers/SYS
    ../Drivers/SYSTERM/sys/: sys.c
    ../Drivers/SYSTERM/delay/: delay.c
    ../Drivers/SYSTERM/usart/: usart1.c
software components: CMSIS:CORE 6.1.0
